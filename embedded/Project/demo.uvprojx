# Keil uVision project demo.uvprojx, settings and files
target demo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F470ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CMSIS\core\inc;..\CMSIS\gd32f4xx\inc;..\Peripherals\inc;..\BSP\inc;..\Application\inc;..\Source\include;..\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Startup/: startup_gd32f450_470.s
  group CMSIS
    ../CMSIS/gd32f4xx/src/: system_gd32f4xx.c
    ../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Source/portable/RVDS/ARM_CM4F/: port.c
    ../Source/portable/MemMang/: heap_4.c
  group Peripherals
    ../Peripherals/src/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group BSP
    ../BSP/src/: u1.c delay.c i2c.c e1.c e2.c e3.c s1.c s2.c s5.c s6.c s7.c s8.c s11.c c3.c uart.c
  group Application
    ../Application/src/: main.c
    ../Application/src/project_classroom/: app_project.c app_control.c app_sensor.c app_wifi.c app_display.c
